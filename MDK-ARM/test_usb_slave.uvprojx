# Keil uVision project test_usb_slave.uvprojx, settings and files
target test_usb_slave (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: test_usb_slave
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Include;    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Middlewares/Third_Party/LwIP/src/include;   ../Middlewares/Third_Party/LwIP/system;   ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;   ../Middlewares/Third_Party/LwIP/src/include/lwip;   ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;   ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;   ../Middlewares/Third_Party/LwIP/src/include/netif;   ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;   ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;   ../Middlewares/Third_Party/LwIP/src/include/posix;   ../Middlewares/Third_Party/LwIP/src/include/posix/sys;   ../Middlewares/Third_Party/LwIP/system/arch; ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_hcd.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_eth.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c usb_host.c ethernetif.c usbh_conf.c lwip.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: des.c arc4.c md4.c md5.c sha1.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: pppcrypt.c chap-new.c ccp.c demand.c mppe.c utils.c pppos.c fsm.c ipv6cp.c upap.c pppoe.c pppol2tp.c chap_ms.c multilink.c ecp.c lcp.c ppp.c magic.c vj.c eap.c chap-md5.c auth.c eui64.c ipcp.c
    ../Middlewares/Third_Party/LwIP/src/core/: raw.c netif.c tcp_out.c mem.c dns.c memp.c udp.c def.c lwip_timers.c tcp.c inet_chksum.c tcp_in.c sys.c stats.c pbuf.c init.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c ip_frag.c icmp.c igmp.c ip4_addr.c ip4.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ethip6.c mld6.c nd6.c ip6_frag.c inet6.c icmp6.c ip6.c dhcp6.c ip6_addr.c
    ../Middlewares/Third_Party/LwIP/src/api/: netifapi.c tcpip.c netdb.c err.c api_lib.c pppapi.c sockets.c netbuf.c api_msg.c
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_pipes.c usbh_core.c usbh_ctlreq.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
software components: CMSIS:CORE 4.1.0
